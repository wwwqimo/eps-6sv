# IAR project Project.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Libraries\CMSIS\Include; ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\User\bsp_stm32f4xx; ..\..\User\bsp_stm32f4xx\inc; ..\..\User; ..\..\uCOS-II\uC-CPU; ..\..\uCOS-II\uC-CPU\ARM-Cortex-M4\IAR; ..\..\uCOS-II\uC-LIB; ..\..\uCOS-II\uC-LIB\Ports\ARM-Cortex-M4\IAR; ..\..\uCOS-II\uCOS-II\Source; ..\..\uCOS-II\uCOS-II\Ports\ARM-Cortex-M4\Generic\IAR
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  postbuild: CopyHex_Flash.bat
  ILINK.IlinkOutputFile: stm32-f4.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CpuRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; VECT_TAB_SRAM; STM32F40_41xxx
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Libraries\CMSIS\Include; ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\User\bsp_stm32f4xx; ..\..\User\bsp_stm32f4xx\inc; ..\..\User
  ILINK.IlinkIcfFile: stm32f4xx_ram.icf
  group BSP
    ../../User/bsp_stm32f4xx/: bsp.c stm32f4xx_it.c
    ../../User/bsp_stm32f4xx/src/: bsp_key.c bsp_led.c bsp_printf.c bsp_uart.c
  group CMSIS
    ../../User/bsp_stm32f4xx/: system_stm32f4xx.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.开发环境说明.txt 04.STM32F407IGT6引脚定义(原始定义).txt 05.GPIO分配表(按GPIO次序排列).txt 06.GPIO分配表(按功能排列).txt
  group EWARMv6
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group uC/CPU
    ../../uCOS-II/uC-CPU/ARM-Cortex-M4/IAR/: cpu.h cpu_a.asm cpu_c.c
    ../../uCOS-II/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    ../../uCOS-II/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../uCOS-II/uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group uC/OS-II Port
    ../../uCOS-II/uCOS-II/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC/OS-II Source
    ../../uCOS-II/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group User
    ../../User/: app.c app_cfg.h app_hooks.c cpu_cfg.h includes.h lib_cfg.h os_cfg.h
