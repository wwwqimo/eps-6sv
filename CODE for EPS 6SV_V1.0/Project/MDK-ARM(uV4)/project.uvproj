# Keil uVision project project.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,ARM_MATH_CM4,__FPU_PRESENT=1,__FPU_USED=1
  c misc: --diag_suppress=870
  c include: ..\..\User;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\User\bsp_stm32f4xx;..\..\User\bsp_stm32f4xx\inc;..\..\uCOS-II\uC-CPU;..\..\uCOS-II\uC-LIB;..\..\uCOS-II\uCOS-II\Source;..\..\uCOS-II\uC-CPU\ARM-Cortex-M4\RealView;..\..\uCOS-II\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\uCOS-II\uCOS-II\Ports\ARM-Cortex-M4\Generic\RealView;..\..\User\user_app;..\..\User\user_app\userbsp;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\DSP_Lib\Source\ControllerFunctions
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: app.c app_cfg.h includes.h lib_cfg.h os_cfg.h app_hooks.c
    ../../User/bsp_stm32f4xx/: stm32f4xx_it.c
  group UserAPP
    ../../User/user_app/: user_cfg.h user_app.h app_adc.c app_mppt.c user_print.c eps_handle.c user_app.c
  group UserBSP
    ../../User/user_app/userbsp/: user_bsp.c user_bsp.h bsp_mppt.c bsp_f4adc.c bsp_pid.c bsp_ad7490.c
  group BSP
    ../../User/bsp_stm32f4xx/: bsp.c bsp.h
    ../../User/bsp_stm32f4xx/src/: bsp_key.c bsp_adc.c bsp_gpio.c bsp_pwm.c bsp_spi.c bsp_uart.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group MATH-ARM
    ../../Libraries/CMSIS/DSP_Lib/Source/ControllerFunctions/: arm_pid_init_f32.c arm_pid_reset_f32.c arm_sin_cos_f32.c
    ../../Libraries/CMSIS/Include/: arm_math.h core_cm4.h
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_iwdg.c stm32f4xx_tim.c stm32f4xx_wwdg.c stm32f4xx_crc.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_dac.c
  group CMSIS
    ../../User/bsp_stm32f4xx/: system_stm32f4xx.c
  group uC/CPU
    ../../uCOS-II/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../uCOS-II/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../uCOS-II/uC-LIB/: lib_mem.c lib_mem.h lib_str.c lib_str.h lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h
    ../../uCOS-II/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/OS-II Source
    ../../uCOS-II/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uC/OS-II Port
    ../../uCOS-II/uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
target CpuRAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: output
  AfterMake: CopyHex_CpuRAM.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,ARM_MATH_CM4,__CC_ARM,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\User\bsp;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
target ExtSRAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: output +hex
  AfterMake: CopyHex_ExtSRAM.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x68000000 size 0x80000
  memory RVCT9: RAM 0x20000200 size 0xffe00
